# Keil uVision project FM175XX_READER_STM32.uvprojx, settings and files
target FM17550 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FM17550 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER , STM32F10X_HD
  c include: ..\LIB\INC;..\INC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../: cortexm3_macro.s STM32F10x.s
  group Code
    ../CODE/: DEVICE_CFG.C FM175XX.c MAIN.c stm32f10x_it.c UART.C READER_API.c MIFARE.c CPU_CARD.c
  group Lib
    ../LIB/CODE/: stm32f10x_usart.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_nvic.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_pwr.c
software components: CMSIS:CORE 5.1.1
